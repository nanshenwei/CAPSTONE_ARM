# Repository nanshenwei/CAPSTONE_ARM

File README.md:

# CAPSTONE_ARM
 repair a CAPSTONE? robot arm

## KiCad design Electronics/CAPSTONE_MC/CAPSTONE_MC.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C7, C8, C9, C21, C38, C39, C40, C41, C54, C55: 2.2uF; C_0402_1005Metric
C6, C46, C47: 1uF; C_0402_1005Metric
C10, C11: 10pF; C_0402_1005Metric
C12, C13, C15, C20, C42, C45: 100nF; C_0402_1005Metric
C14: 2.2uF 50V; C_0603_1608Metric
C16, C34: 22uF; C_0805_2012Metric
C17: 100nF 450V; C_1206_3216Metric
C18: 10uF; C_0603_1608Metric
C19, C29: 22uF; C_0402_1005Metric
C22: 47pF DNP; C_0402_1005Metric; not fitted
C23, C24, C25: 220nF; C_0402_1005Metric
C26, C27, C28: 1uF; C_0603_1608Metric
C30, C31, C32, C48, C50: 2.2uF 450V; C_2220_5750Metric
C33, C51: 10uF; C_0402_1005Metric
C35, C36, C37: 4.7nF; C_0402_1005Metric
C43, C44: 33pF; C_0402_1005Metric
C52: C_Polarized
C53, C56, C57, C58: 10nF; C_0402_1005Metric
C59, C60: 47uF; C_1206_3216Metric
D1, D3: SURS8360BT3G; D_SMB
D2: 10V BZT52C10; D_SOD-123
D4: SS24L; D_SOD-123F
D5: BLUE; LED_0402_1005Metric
D6: RED; LED_0402_1005Metric
D7: GREEN; LED_0402_1005Metric
D8, D9, D10: US1JW; D_SOD-123F
D11: PESD1CAN; SOT-23
D12: SMBJ350CA; D_SMB
H1, H2, H3: MountingHole; MountingHole_2.2mm_M2
L1: 0R; L_0402_1005Metric
L2: 1mH >600mA; L_Bourns_SRN8040TA
L3: 10uH >1.2A <200mR; L_Abracon_ASPI-0425
NT1: NetTie_2; NetTie-2_SMD_Pad0.5mm
R1: 1R; R_1206_3216Metric
R2: 13K; R_0402_1005Metric
R3: 3K4; R_0402_1005Metric
R4, R5, R6, R13, R14, R15: 1K; R_0402_1005Metric
R7, R8, R9: 1R; R_0805_2012Metric
R10, R11, R12: 8mR; R_1206_3216Metric
R16, R17: 10K; R_0402_1005Metric
R20: 120R; R_0402_1005Metric
R21: 0R; R_0402_1005Metric
R22, R24, R26, R28: 499K; R_2010_5025Metric
R23, R25, R27, R29: 3K6; R_0402_1005Metric
R30, R31: 3K3; R_0402_1005Metric
R32, R33: 22R; R_0402_1005Metric
SYM1: Logo_Open_Hardware_Small; OSHW-Logo_5.7x6mm_SilkScreen_noText
SYM3: SYM_Flash_Large; Symbol_HighVoltage_NoTriangle_2x5mm_Copper
SYM5: Logo_Open_Hardware_Small; KiCad-Logo_5mm_SilkScreen
TH1: 10K_NTC; R_0805_2012Metric
TH2: 10K_NTC or CNT; R_0805_2012Metric
TP1, TP2: TestPoint; TestPoint_THTPad_D3.0mm_Drill1.5mm
TP3, TP4, TP5, TP13, TP16: TestPoint; TestPoint_THTPad_D2.0mm_Drill1.0mm
TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP20, TP21: TestPoint; TestPoint_Pad_D1.0mm
U1: STM32F405RGTx; LQFP-64_10x10mm_P0.5mm
U2, U3, U4: LAS1M0750; LasSOP-10
U5, U6, U7: INA181A1; SOT-23-6
U8: AS5047P; TSSOP-14_4.4x5mm_P0.65mm
U9: SN65HVD232; SOIC-8_3.9x4.9mm_P1.27mm
U10: EG1120; SOT-23-3
U11: LGS5145; SOT-23-6
U12: XC6220B331MR; SOT-23-5
U13: LMV321; SOT-23-5
Y1: Crystal_GND24; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3VA: C5.1, C6.2, C7.1, C21.1, C38.1, C39.1, C47.1, L1.1, R30.1, TH1.1, TH2.1, U1.13 (VDDA), U5.6 (V+), U6.6 (V+), U7.6 (V+), U13.5 (V+)
+3V3: C1.1, C2.1, C3.1, C4.1, C13.1, C33.1, C42.1, C45.1, C51.1, L1.2, R4.1, U1.1 (VBAT), U1.19 (VDD), U1.32 (VDD), U1.48 (VDD), U1.64 (VDD), U8.11 (VDD), U8.12 (VDD3V3), U9.3 (VCC), U12.5 (VOUT)
+3V8: C19.1, C22.1, C29.1, C54.1, C55.1, L3.2, R2.1, TP21.1, U12.1 (VIN), U12.3 (CE)
+15V: C15.1, C16.1, C18.1, C26.1, C27.1, C28.1, C34.1, C59.1, C60.1, D3.2 (A), L2.2, R7.2, R8.2, R9.2, U2.5 (VCC), U3.5 (VCC), U4.5 (VCC), U11.4 (EN), U11.5 (VIN)
/ADC_15: U1.25 (PC5)
/ADC_TEMP: C40.1, R16.1, TH1.2, U1.17 (PA3)
/AN_IN: C53.1, R22.1, R23.1, U1.11 (PC3)
/BTN: U1.2 (PC13)
/CANH: C43.1, D11.1 (A1), R20.1, TP13.1, U9.7 (CANH)
/CANL: C44.2, D11.2 (A2), R21.2, TP16.1, U9.6 (CANL)
/CAN_RX: U1.61 (PB8), U9.4 (R)
/CAN_TX: U1.62 (PB9), U9.1 (D)
/CURRENT_1: C37.1, R15.1, U1.8 (PC0)
/CURRENT_2: C36.1, R14.1, U1.9 (PC1)
/CURRENT_3: C35.1, R13.1, U1.10 (PC2)
/C_A: R15.2, U7.1
/C_B: R14.2, U6.1
/C_C: R13.2, U5.1
/H1: U1.41 (PA8), U2.6 (INH)
/H2: U1.42 (PA9), U3.6 (INH)
/H3: U1.43 (PA10), U4.6 (INH)
/HALL_1: U1.37 (PC6)
/HALL_2: U1.38 (PC7)
/HALL_3: U1.39 (PC8)
/HS1: C25.2, R24.2, TP3.1, U2.2 (SW)
/HS2: C23.2, R26.2, TP4.1, U3.2 (SW)
/HS3: C24.2, R28.2, TP5.1, U4.2 (SW)
/HVBUS: C17.1, C30.1, C31.1, C32.1, C48.1, C50.1, C52.1, D12.2 (A2), R22.2, TP1.1, U2.3 (VIN), U3.3 (VIN), U4.3 (VIN), U10.1 (Drain)
/L1: U1.34 (PB13), U2.7 (INL)
/L2: U1.35 (PB14), U3.7 (INL)
/L3: U1.36 (PB15), U4.7 (INL)
/LED_GREEN: R6.1, U1.26 (PB0)
/LED_RED: R5.1, U1.27 (PB1)
/MISO_ADC_EXT2: U1.22 (PA6), U8.3 (MISO)
/OSC_IN: C10.1, U1.5 (PH0), Y1.1
/OSC_OUT: C11.1, U1.6 (PH1), Y1.3
/RX_SDA_NSS: U1.20 (PA4), U8.1 (~CS)
/SCK_ADC_EXT: U1.21 (PA5), U8.2 (CLK)
/SPI3_CS: U1.40 (PC9)
/SPI3_MISO: U1.52 (PC11)
/SPI3_MOSI: U1.53 (PC12)
/SPI3_SCK: U1.51 (PC10)
/SWCLK: TP11.1, U1.49 (PA14)
/SWDIO: TP10.1, U1.46 (PA13)
/TEMP_MOTOR: C41.1, R17.1, TH2.2, U1.24 (PC4)
/TX_SCL_MOSI: U1.23 (PA7), U8.4 (MOSI)
/U1_RX_FAULT: TP8.1, U1.59 (PB7)
/U1_TX_SERVO: TP9.1, U1.58 (PB6)
/USB_DM: R32.2, U1.44 (PA11)
/USB_DP: R33.2, U1.45 (PA12)
/VOLTAGE_1: C56.1, R24.1, R25.1, U1.14 (PA0)
/VOLTAGE_2: C57.1, R26.1, R27.1, U1.15 (PA1)
/VOLTAGE_3: C58.1, R28.1, R29.1, U1.16 (PA2)
/Vref: U5.5 (REF), U6.5 (REF), U7.5 (REF), U13.3 (-), U13.4
/nRST: C12.1, U1.7 (NRST)
GND: C1.2, C2.2, C3.2, C4.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C15.2, C16.2, C17.2, C18.2, C19.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C42.2, C43.2, C44.1, C45.2, C48.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, D1.2 (A), D4.2 (A), D5.1 (K), D6.1 (K), D7.1 (K), D11.3 (common), D12.1 (A1), NT1.1, R3.1, R10.2, R11.2, R12.2, R23.2, R25.2, R27.2, R29.2, TP2.1, TP12.1, TP20.1, U1.18 (VSS), U1.60 (BOOT0), U1.63 (VSS), U2.10 (GND), U3.10 (GND), U4.10 (GND), U5.4 (-), U6.4 (-), U7.4 (-), U8.5 (TST), U8.13 (GND), U9.2 (GND), U11.2 (GND), U12.2 (GND), Y1.2, Y1.4
GNDA: C5.2, C6.1, C7.2, C21.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C46.2, C47.2, NT1.2, R16.2, R17.2, R31.2, U1.12 (VSSA), U5.2 (GND), U6.2 (GND), U7.2 (GND), U13.2 (V-)
unnamed: C14.1, D1.1 (K), L2.1, R1.2
unnamed: C14.2, D2.2 (A), U10.2 (VDD)
unnamed: D2.1 (K), D3.1 (K)
unnamed: C20.2, D4.1 (K), L3.1, U11.6 (SW)
unnamed: D5.2 (A), R4.2
unnamed: D6.2 (A), R5.2
unnamed: D7.2 (A), R6.2
unnamed: D8.2 (A), R7.1
unnamed: C23.1, D8.1 (K), U3.4 (BST)
unnamed: D9.2 (A), R8.1
unnamed: C24.1, D9.1 (K), U4.4 (BST)
unnamed: D10.2 (A), R9.1
unnamed: C25.1, D10.1 (K), U2.4 (BST)
unnamed: R20.2, R21.1
unnamed: R32.1, TP6.1
unnamed: R33.1, TP7.1
unnamed: C9.1, U1.31 (VCAP_1)
unnamed: C8.1, U1.47 (VCAP_2)
unnamed: R12.1, U2.1 (VS), U7.3 (+)
unnamed: R11.1, U3.1 (VS), U6.3 (+)
unnamed: R10.1, U4.1 (VS), U5.3 (+)
unnamed: R1.1, U10.3 (CS)
unnamed: C20.1, U11.1 (BST)
unnamed: C22.2, R2.2, R3.2, U11.3 (FB)
unnamed: C46.1, R30.2, R31.1, U13.1 (+)

Notes on the sheet:
INVERTER
INDICATOR LED
MCU
TEMPERATURE
VOLTAGE REF
POWER
ENCODER
SYMBOL
INTERFACE
CAN PHY
修正为3.9167V
VOLTAGE DIVIDER NETWORK & FILTER

Board: 6 copper layers, 52.0 x 52.0 mm, 143 parts (29 on the bottom side), 73 nets.

## KiCad design Electronics/RegenClamp/Regen Clamp.kicad_pcb

Parts:
C1: 2.2uF 450V; C_2220_5750Metric
C2: 100nF 450V; C_1206_3216Metric
C3: 100nF; C_0402_1005Metric; mpn C106861
C4: 1uF; C_0402_1005Metric; mpn C110251
C5, C18: 100nF; C_0402_1005Metric; mpn C110251
C6: 2.2uF; C_0603_1608Metric
C7, C8: 47uF; C_1206_3216Metric
C9, C10: 22uF; C_0805_2012Metric
C11, C17: 100nF; C_0402_1005Metric
C12: 330nF; C_0603_1608Metric
C13: 1uF; C_0402_1005Metric
C14, C15, C16: 1uF; C_0402_1005Metric; mpn C1530
C19, C20, C21, C22, C23, C24: 150uF 450V; CP_Radial_D18.0mm_P7.50mm
D1: SMBJ350CA; D_SMB
D2, D3: ES10J; D_SMC
D4, D7: SURS8360BT3G; D_SMB
D5: BZT52C10; D_SOD-123
D6: 1N4148W; D_SOD-123
D8, D9, D10: LED; LED_0603_1608Metric
F1: 0477005.MXP
J1: SW; WJ500V-5.08-2P
J2: VIN; WJ500V-5.08-2P
J3: R_DIS+; T44001
J4: R_DIS-; T44001
J5: VOUT; WJ500V-5.08-2P
J6: R_PRE+; T44001
J7: R_PRE-; T44001
K1: G2RL-1-E-DC12; Relay_SPDT_Omron_G2RL-1-E
L1: 1mH >600mA; L_Bourns_SRN8040TA
LOGO1: LOGO; RLX_logo-bird
Q1: BSS138; SOT-23
Q2: IRF740STRLPBF; TO-263-2
R1, R3, R6: 10k; R_0402_1005Metric; mpn C122969
R2: 1k; R_0402_1005Metric; mpn C122969
R4: 1R; R_1206_3216Metric
R5: 10R; R_0402_1005Metric; mpn C122969
R7: 12k; R_0402_1005Metric; mpn C122969
R8: 15k; R_0402_1005Metric; mpn C122969
R9: 5k; R_0402_1005Metric; mpn C122969
R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21: 82k; R_2512_6332Metric; mpn C723482
R22, R23, R24: 10k; R_1206_3216Metric; mpn C870718
RV3: 10k; TRIM_3296W
TP1, TP2, TP3, TP4, TP5, TP6, TP7: TP; TestPoint_Pad_D1.0mm
U1: OPA2197xD; SOIC-8_3.9x4.9mm_P1.27mm
U2: EG1120; SOT-23-3
U3: UCC27517DBVR; SOT-23-5
U4: L7812; TO-252-2

Connections:
+12V: C13.2, C17.2, D6.1 (K), K1.A1, R7.1, TP4.1, U4.3 (OUT); also elsewhere on the board
+15V: C4.2, C5.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.2, C18.1, D7.2 (A), L1.2, TP1.1, U1.8 (V+), U3.1 (V_{DD}), U4.1 (IN); also elsewhere on the board
/DIS: R1.2, R9.1, U3.3 (IN+); also elsewhere on the board
/PRE: R2.1, R8.1, U1.1
/VIN_REF: C14.1, R19.2, R22.2, TP5.1, U1.2 (-)
/VOUT_REF_PRE: C15.1, R20.2, R23.2, TP6.1, U1.3 (+)
unnamed: C6.1, D4.1 (K), L1.1, R4.2
unnamed: C6.2, D5.2 (A), U2.2 (VDD)
unnamed: D5.1 (K), D7.1 (K)
unnamed: D6.2 (A), K1.A2, Q1.3 (D)
unnamed: D8.2 (A), R7.2
unnamed: D9.2 (A), R8.2
unnamed: D10.2 (A), R9.2
unnamed: C3.1, Q1.1 (G), R2.2, R3.2
unnamed: Q2.1 (G), R5.2, R6.2
unnamed: R10.2, R13.1
unnamed: R11.2, R14.1
unnamed: R12.2, R15.1
unnamed: R13.2, R16.1
unnamed: R14.2, R17.1
unnamed: R15.2, R18.1
unnamed: R16.2, R19.1
unnamed: R17.2, R20.1
unnamed: R18.2, R21.1
unnamed: R23.1, RV3.2
unnamed: R4.1, U2.3 (CS)
unnamed: R5.1, U3.5 (OUT)
R_DISCHARGE-: J4.1, Q2.2 (D)
R_PRECHARGE+: D2.1 (K), D3.1 (K), J6.1, K1.14
R_PRECHARGE-: J7.1, K1.12
SW1: J1.2, J2.1
SW2: F1.2, J1.1
VIN+: C1.1, C2.1, D1.2 (A2), D2.2 (A), D3.2 (A), F1.1, R10.1, TP2.1, U2.1 (Drain); also elsewhere on the board
VIN-: C1.2, C2.2, C3.2, C4.1, C5.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.1, C13.1, C14.2, C15.2, C16.2, C17.1, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, D1.1 (A1), D4.2 (A), D8.1 (K), D9.1 (K), D10.1 (K), J2.2, J5.2, Q1.2 (S), Q2.3 (S), R1.1, R3.1, R6.1, R22.1, R24.1, RV3.3, U1.4 (V-), U3.2 (GND), U3.4 (IN-), U4.2 (GND); also elsewhere on the board
VOUT+: C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, J3.1, J5.1, K1.11, R11.1, R12.1, TP3.1
VOUT_REF_DIS: C16.1, R21.2, R24.2, TP7.1; also elsewhere on the board

Notes on the sheet:
漏源电压：400V 连续漏极电流：10A VGSth：4V
9.32611312÷0.03588517=259.88766725V
最大切换电压：440V@AC；300V@DC

Parts:
C25, C30: 100nF; C_0402_1005Metric; mpn C110251
C26, C28: 22uF; C_0805_2012Metric
C27: 22nF; C_0402_1005Metric
C29, C31: 1uF; C_0402_1005Metric; mpn C1530
FID1, FID2, FID3, FID4: Fiducial; Fiducial_1mm_Mask2mm
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
L2: 10uH; L_FTC252010S4R7MBCA
R25: 110k; R_0402_1005Metric
R26: 15k; R_0402_1005Metric
R27, R28: 22k; R_0402_1005Metric; mpn C122969
R29, R30: 10k; R_0402_1005Metric; mpn C122969
R31, R32, R33, R35, R37, R38, R39, R41: 82k; R_2512_6332Metric; mpn C723482
R36, R42: 10k; R_1206_3216Metric; mpn C870718
RV1, RV2: 500R; TRIM_3296W
TP8, TP9, TP10, TP11, TP12: TP; TestPoint_Pad_D1.0mm
U5: OPA2197xD; SOIC-8_3.9x4.9mm_P1.27mm
U6: MT2492; SOT-23-6
U7: SN74LVC2G02DCUR; VSSOP-8_2.3x2mm_P0.5mm

Connections:
+5V: C28.1, C30.1, L2.2, R25.1, TP8.1, U7.8 (VCC)
+12V: C26.1, U6.4 (EN), U6.5 (IN); also elsewhere on the board
+15V: C25.1, U5.8 (V+); also elsewhere on the board
/Comparator/R: R27.2, R29.2, TP9.1, U7.1
/Comparator/S: R28.2, R30.2, TP10.1, U7.6
/Comparator/VIN_REF_H: C29.1, R35.2, R36.2, TP11.1, U5.6 (-)
/Comparator/VIN_REF_L: C31.1, R41.2, R42.2, TP12.1, U5.3 (+)
/DIS: U7.5, U7.7; also elsewhere on the board
unnamed: R27.1, U5.1
unnamed: R28.1, U5.7
unnamed: R31.2, R32.1
unnamed: R32.2, R33.1
unnamed: R33.2, R35.1
unnamed: R36.1, RV1.2
unnamed: R37.2, R38.1
unnamed: R38.2, R39.1
unnamed: R39.2, R41.1
unnamed: R42.1, RV2.2
unnamed: C27.1, U6.1 (BS)
unnamed: R25.2, R26.1, U6.3 (FB)
unnamed: C27.2, L2.1, U6.6 (SW)
unnamed: U7.2, U7.3
VIN+: R31.1, R37.1; also elsewhere on the board
VIN-: C25.2, C26.2, C28.2, C29.2, C30.2, C31.2, R26.2, R29.1, R30.1, RV1.3, RV2.3, U5.4 (V-), U6.2 (GND), U7.4 (GND); also elsewhere on the board
VOUT_REF_DIS: U5.2 (-), U5.5 (+); also elsewhere on the board

Board: 4 copper layers, 100.0 x 90.0 mm, 125 parts (0 on the bottom side), 55 nets.

## Code that names these connections

File Software/CAPSTONE_MC_SW/CAPSTONE_MC_SW.ioc (part):

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Mcu.Name=STM32F405RGTx
Mcu.Package=LQFP64
Mcu.UserName=STM32F405RGTx
PA0-WKUP.Signal=ADCx_IN0
PA1.Signal=ADCx_IN1
PA10.Signal=S_TIM1_CH3
PA11.Mode=Device_Only
PA11.Signal=USB_OTG_FS_DM
PA12.Mode=Device_Only
PA12.Signal=USB_OTG_FS_DP
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA2.Signal=ADCx_IN2
PA3.Signal=ADCx_IN3
PA4.Mode=NSS_Signal_Hard_Output
PA4.Signal=SPI1_NSS
PA5.Mode=Full_Duplex_Master
PA5.Signal=SPI1_SCK
PA6.Mode=Full_Duplex_Master
PA6.Signal=SPI1_MISO
PA7.Mode=Full_Duplex_Master
PA7.Signal=SPI1_MOSI
PA8.Signal=S_TIM1_CH1
PA9.Signal=S_TIM1_CH2
PB0.Signal=GPIO_Output
PB1.Signal=GPIO_Output
PB13.Mode=PWM Generation1 CH1 CH1N
PB13.Signal=TIM1_CH1N
PB14.Mode=PWM Generation2 CH2 CH2N
PB14.Signal=TIM1_CH2N
PB15.Mode=PWM Generation3 CH3 CH3N
PB15.Signal=TIM1_CH3N
PB6.Signal=USART1_TX
PB7.Signal=USART1_RX
PB8.Mode=CAN_Activate
PB8.Signal=CAN1_RX
PB9.Mode=CAN_Activate
PB9.Signal=CAN1_TX
PC0.Signal=ADCx_IN10
PC1.Signal=ADCx_IN11
PC2.Signal=ADCx_IN12
PC3.Signal=ADCx_IN13
PC4.Signal=ADCx_IN14
PC5.Signal=ADCx_IN15
PH0-OSC_IN.Mode=HSE-External-Oscillator
PH0-OSC_IN.Signal=RCC_OSC_IN
PH1-OSC_OUT.Mode=HSE-External-Oscillator
PH1-OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=168000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log

2024-01-20 create
2024-01-28 update datasheet
2024-08-02 update asset
2025-06-23 删除所有 .DS_Store 文件
2025-06-23 1. 更新PCB v1.0.0 2. 更新规格书
